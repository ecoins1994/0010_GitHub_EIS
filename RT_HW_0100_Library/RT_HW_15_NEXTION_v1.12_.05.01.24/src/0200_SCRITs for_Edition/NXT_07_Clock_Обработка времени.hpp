//++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
//									Параметры времени
//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
//
//						ПРИВЯЗКА ПАРАМЕТРОВ ВРЕМЕНИ
//
//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
mMotor=in3
mTime=in4
mDate=in5
mUNIX=in6
//==================================================================================================
//             	4.Формирование параметров даты txtData.txt
//==================================================================================================
vTXT.txt=" "
//--------------------------------------------------------------------------------------------------
//				4.1. День недели
//--------------------------------------------------------------------------------------------------
sys0=mDate>>24
sys0&=0xFF
if(sys0==0)
{
vTXT.txt+="Воскресение"
}
if(sys0==1)
{
vTXT.txt+="Понедельник"
}
if(sys0==2)
{
vTXT.txt="Вторник"
}
if(sys0==3)
{
vTXT.txt="Среда"
}
if(sys0==4)
{
vTXT.txt="Четверг"
}
if(sys0==5)
{
vTXT.txt="Пятница"
}
if(sys0==6)
{
vTXT.txt="Суббота"
}
vTXT.txt+=" "
//--------------------------------------------------------------------------------------------------
//				4.2. День
//--------------------------------------------------------------------------------------------------
sys0=mDate>>16
sys0&=0xFF
covx sys0,vSTR.txt,2,0
vTXT.txt+=vSTR.txt+"."
//--------------------------------------------------------------------------------------------------
//				4.3. Месяц
//--------------------------------------------------------------------------------------------------
sys0=mDate>>8	
sys0&=0xFF
covx sys0,vSTR.txt,2,0
vTXT.txt+=vSTR.txt+"."
//--------------------------------------------------------------------------------------------------
//				4.4. Год (2 знака)
//--------------------------------------------------------------------------------------------------
vTXT.txt+="20"
sys0=mDate
sys0&=0xFF
covx sys0,vSTR.txt,2,0
vTXT.txt+=vSTR.txt
//-------------------------------------
txtData.txt=vTXT.txt			//--Присвоение полю значения;

//==================================================================================================
//             	5.Формирование параметров времени txtTime.txt
//==================================================================================================
vTXT.txt=" "
//--------------------------------------------------------------------------------------------------
//				5.1.Час
//--------------------------------------------------------------------------------------------------
sys0=mTime>>16
sys0&=0xFF
covx sys0,vSTR.txt,2,0
vTXT.txt+=vSTR.txt+"."
//--------------------------------------------------------------------------------------------------
//				5.2.Минуты
//--------------------------------------------------------------------------------------------------
sys0=mTime>>8
sys0&=0xFF
covx sys0,vSTR.txt,2,0
vTXT.txt+=vSTR.txt+"."
//--------------------------------------------------------------------------------------------------
//				5.3.Секунды
//--------------------------------------------------------------------------------------------------
sys0=mTime
sys0&=0xFF
covx sys0,vSTR.txt,2,0
vTXT.txt+=vSTR.txt
//-------------------------------------
txtTime.txt=vTXT.txt			//--Присвоение полю значения;
//==================================================================================================

//==================================================================================================
//             	6.Формирование параметров времени txtUNIX.txt
//==================================================================================================
vTXT.txt="UNIX:"
//--------------------------------------------------------------------------------------------------
sys0=mUNIX>>16
sys0&=0xFFFF                                       
covx sys0,vSTR.txt,0,0
vTXT.txt+=vSTR.txt
sys0=mUNIX
sys0&=0xFFFF  
covx sys0,vSTR.txt,0,0
vTXT.txt+=vSTR.txt
//-------------------------------------
//txtUNIX.txt=vTXT.txt			//--Присвоение полю значения;
//==================================================================================================

//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
//						02.MAIN Главная (Main) период=100
//+++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++++
//=================================================================================================
//		1. Четырех стадийная анимация индикатора живучести Nextion (период=400)
//=================================================================================================
sys0=0
//-------------------------------------
nBlinkCnt++
if(nBlinkCnt>=4)
{
 sys0=1
}
//-------------------------------------
if(sys0>0)
{
nBlinkCnt=0
nBlinkNum++
if(nBlinkNum>3)
{
nBlinkNum=0
}
//-------------------------------------
if(nBlinkNum==0)
{
blink.pic=2
}else if(nBlinkNum==1)
{
blink.pic=3
}else if(nBlinkNum==2)
{
blink.pic=2
}else if(nBlinkNum==3)
{
blink.pic=3
}
//--------------------------------------
}
//=================================================================================================
//		2.Отправка номера страницы по изменению или периодически (3сек)
//=================================================================================================
sys0=0
//-------------------------------------
nPageCnt++
if(nPageCnt>=30)
{
 sys0=1
}
//-------------------------------------
if(nPageNum!=dp)
{
  sys0=1
}
//-------------------------------------
if(sys0>0)
{
  nPageCnt=0
  sendme  		
}
//==============================================================

